# Keil uVision project smart_railways.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: smart_railways +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s admin.c admin.h defines.h delay.c delay.h eint.c eint.h eint_defines.h kpm.c kpm.h kpm_defines.h lcd.c lcd.h lcd_defines.h main.c rtc.c rtc.h rtc_defines.h status.c status.h status_defines.h train_db.c train_db.h types.h
